# Repository ntakao2006-web/RaceCapture (continued)

## KiCad design circuit/logger_v2_ups/logger_v2_ups.kicad_pcb (continued)

Board: 2 copper layers, 68.6 x 53.3 mm, 40 parts (5 on the bottom side), 15 nets.

## KiCad design circuit/actibe_cooler/actibe_cooler.kicad_pcb

Parts:
C1: 100u; CP_Elec_5x5.9
C2: 0.1u; C_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: Conn_01x04_Pin; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J2: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J3: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
U1: PIC12F1822-xSN; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C1.1, C2.1, J1.2, J2.2, J3.2, U1.1 (VDD)
/ICSPDAD: J3.4, U1.7 (RA0)
/MCLR: J3.1, U1.4 (RA3)
/PWM: J2.4, U1.2 (RA5)
/SCL/ICSPCLK: J1.4, J3.5, U1.6 (RA1)
/SDA: J1.3, U1.5 (RA2)
/TACH: J2.3, U1.3 (RA4)
GND: C1.2, C2.2, J1.1, J2.1, J3.3, U1.8 (VSS)

Board: 2 copper layers, 29.0 x 18.0 mm, 10 parts (0 on the bottom side), 8 nets.

## KiCad design circuit/logger_v1/logger_v1.kicad_pcb

File circuit/logger_v1/README.md:

# logger_v1.net 受領記録

## 概要

- **受領日**：2026-08-14（電気・回路系担当の友人 lintaroh より受領）
- **ファイル情報**：KiCadエクスポートのネットリスト（Eeschema 9.0.6）。rev A / v1。回路図自体の作成日は2026-08-14
- **タイトル**：RaceCapture Compatible Data Logger / ESP32-S3
- **友人環境での元パス**：`C:\Users\lintaroh\Documents\datalogger\circuit\logger_v1\logger_v1.kicad_sch`

メインロガー基板（`ARCHITECTURE.md`6章「製作を依頼したい基板一覧」の1枚目）の初回設計案として送付されたもの。KiCadの回路図(`.kicad_sch`)本体は友人側の環境にのみ存在し、こちらにはネットリスト(`.net`)のみが共有されている。

## このファイルを受けて確認・決定した内容（2026-08-14〜2026-08-16）

`logger_v1.net`のネットリスト解析、および友人・lintarohとの会話を通じて、以下を確認・決定した。詳細と最新状態は`ARCHITECTURE.md`4章「メインロガー基板の回路設計」・`hardware_interface_spec.md`を参照（このファイルは受領時点の一次資料として保存するのみで、以後の更新はARCHITECTURE.md側で追う）。

- メインマイコンは ESP32-S3-DevKitC-1ボードではなく、ESP32-S3-WROOM-1-N16R8モジュールを直接実装するフルカスタム基板と判明
- GNSS：STMicroelectronics Teseo-LIV3FLに確定（UART接続、CR2032バックアップ電池付き）
- IMU：Bosch BNO055（9軸、UART接続）に確定（従来のLSM6DSV16X/I2Cから変更）
- CAN 2系統：車載CAN＝MCP2562FD-E/P（単体トランシーバ）、外部CAN＝MCP25625T-E/SS（SPIコントローラ+トランシーバ一体型）
- 車載CAN側に120Ω終端抵抗(R41)が実装されていた件 → ハンダジャンパーで有無を切り替え可能な方式に決定
- 外部CANバスの電源ラインを3.3Vから5Vへ変更
- USB表示器出力(J5)をType-BからType-C（USB OTG構成）へ変更
- USB電源入力の規格はPDではなくQC（Quick Charge）と判明。12V-1.5A（18W）にネゴシエーションし、DCDCコンバータで5V→三端子レギュレータで3.3Vへ降圧する2段構成
- 車両側の給電構成を決定：ロードスターはシガーソケット充電器でモバイルバッテリーを充電し毎回着脱で給電、エコマイレッジチャレンジ車両はシガーソケット充電器から直接給電（バッテリー分離のためクランキング対策不要）
- SDカードソケット：Molex 47219-2001（金属カバー固定式）に確定
- GNSSアンテナ：現状の回路はパッシブアンテナ仕様。将来的にアクティブ／パッシブ両対応の切り替え可能回路を目指す方針
- ステータスLEDの参照元をRaceCapture/Pro MK3に決定
- グラウンド設計：車載CAN(J6)・外部CAN(J4)のGNDが基板の共通GNDに直結されている実態を確認。対策は検討中
- IMUの実装方式（基板直付け／モジュール化）、磁力計とケーシングのアルミシールドの影響について論点整理

## 関連ドキュメント

- `ARCHITECTURE.md` 4章「メインロガー基板の回路設計」
- `hardware_interface_spec.md`（友人との認識合わせ用の仕様書、3章に未確定事項の最新状態あり）
- `archive/can_termination_check.md`（終端抵抗の件で友人へ送付した確認資料）

## 改訂版受領記録（2026-08-16）

- **受領日**：2026-08-16（友人 lintaroh より更新版を受領。KiCadエクスポート日時は2026-08-16T23:51:48+0900）
- **注意**：title_block内のrev表記（`rev A / v1`、回路図作成日`2026-08-14`）は前回受領時から変わっていない。ファイル自体は大幅に更新されているため、リビジョン番号が更新されていない点は友人に確認・依頼する余地あり（本セクションの日付でバージョンを区別している）。

### 差分解析で確認できた変更点（tstamp基準でコンポーネント個体を追跡し、単なる部品番号振り直しと実質的な変更を区別済み）

**A. 既にARCHITECTURE.md 4章で確定済みの決定と整合する変更（想定通り）**
- GNSSモジュールを Teseo-LIV3FL → **MAX-M10M-00B** へ変更（同一シンボル個体の値変更として反映されている）。6e473c4の決定と一致
- GNSSバックアップ電池(BT1, CH004-2032LFホルダー)を完全撤去。d40fc54「GNSSバックアップ電源は非搭載」の決定と一致
- GNSSアンテナのアクティブ/パッシブ切替え回路（L1チョークコイルによるバイアスT、LNA_EN、VCC_RF）が新規追加。4章の「アクティブ/パッシブ切り替え可能回路を目指す」方針の具体化と見られる

**B. ARCHITECTURE.mdに未反映・友人への確認を推奨する変更**
1. **車載CAN(J4)・外部CAN(J5)のコネクタが JST VH → Molex Micro-Fit 3.0 (43045-0400, 2x2・4極) に変更されている。** ユーザー側メモでは外部CANはJST VH(4極)を仮採用しており、購入済み4芯ケーブル(AWG22/24混在)のAWG24芯線がVHの標準圧着端子（SVH-21T-P1.1等）の対応範囲外という懸念が未解決のまま残っていた。今回のMicro-Fit 3.0への変更がこの懸念を踏まえた意図的な変更なのか、友人が単に把握せず別コネクタを選定したのかは要確認。ハウジング形状も1x4→2x2に変わるため、購入済みケーブル・端子との適合性も要再確認
2. 車載CAN用トランシーバICが **MCP2562FD-E/P(DIP-8) → ATA6561-GAQW-N(SOIC-8)** に変更。機能上は同種の高速CANトランシーバで問題なさそうだが、ARCHITECTURE.mdの記載（3章の構成要素表）は旧型番のまま
3. **外部/車載CAN系統の5V供給ラインにあった保護ヒューズ F1・F2（Littelfuse LVR200S、2A保持型PTC）が削除**され、代替の保護素子も見当たらない。車体を這わせる外部ハーネス側の電源ラインから過電流保護が失われている可能性があり、意図的な簡略化か削除し忘れかを友人に確認することを推奨
4. USB Type-Cの役割判定・CC検出方式が、ディスクリートのアナログマルチプレクサ(CD74HC4053E)+抵抗分圧による自作回路から、**専用IC TUSB320IRWBR（Type-C CCロジックコントローラ）** を使う方式に刷新されている。関連する抵抗分圧網も再設計されている。望ましい簡素化・信頼性向上に見えるが未ドキュメント化
5. 3.3Vレギュレータが **LM2940T-3.3(TO-220, 1A定格) → BP5293-33(SIP3, 定格500mA程度)** に変更。ESP32-S3＋GNSS＋IMU＋CAN×2＋SDカード書き込みが重なるピーク電流が500mA以内に収まる想定か、友人側で検討済みか確認推奨
6. ほぼ全ての抵抗・電解/積層コンデンサがスルーホール(THT)からSMDフットプリントへ一括変換されている。量産・実装性向上として好ましい変化だが、電源平滑用コンデンサの一部は値も同時に変わっている（100u/1u系の混在 → 47u系へ整理など）ため、電源平滑設計の見直しとして意図的か確認要

**C. 軽微で確認不要と判断した変更**
- ステータスLED回路が単純なGPIO直結からシフトレジスタ(TC74HC595AF)+LED8灯構成に刷新。SER/SRCLKはCAN2用SPIバス(MCP25625T-E/SS)と共有だが、RCLK(ラッチ)・~OE・~SRCLRは独立配線されており設計上の問題は見当たらない。RaceCapture/Pro MK3参照方針と整合
- VBUS検出用分圧抵抗を5.1k/49.9k→49.9k/4.99kへ微調整（より標準的な10:1比へ）
- U2(LDR6321)のフットプリントをSSOP-16の正しいピッチへ修正（4.4x5.2mm→3.9x4.9mm）

### 次のアクション
上記B節の5項目について、友人への確認事項リストとして`hardware_meeting_agenda.md`または個別メッセージでの確認を推奨。確定した内容から順次`ARCHITECTURE.md`4章へ反映する。

## 基板STEPファイルの格納（2026-08-18）

回路設計・レイアウト協議が完了し発注待ちの段階で、友人から基板の物理レイアウトデータ（STEPファイル、約37.6MB）を受領し、`circuit/logger_v1/logger_v1.step`として格納した。ファイルサイズが大きいため、Git LFS（`.gitattributes`で`*.step`/`*.stp`を追跡対象に設定済み）経由で管理する。Phase4-4-4（ロガー試作筐体の3Dモデル設計）で使用する。

Parts:
C1, C8, C14, C16, C18: 47u; CP_Elec_6.3x5.8
C2, C3, C6, C9, C10, C12, C13, C15, C17, C22, C26, C27, C28, C29, C33, C36: 0.1u; C_0603_1608Metric
C4: 4.7u; C_0805_2012Metric
C5: 22u; CP_Elec_5x5.4
C7, C19, C20, C23: 1u; C_0805_2012Metric
C11, C21: 1n; C_0603_1608Metric
C24, C25: 33p; C_0603_1608Metric
C32: 100u; CP_Radial_D6.3mm_P2.50mm
C34: 10nF; C_0603_1608Metric
D1: PMEG4010CEGWJ; D_SOD-123; MPN PMEG4010CEGWJ; DigiKey 1727-7338-1-ND
D2, D3: PEC3824C2A-AU; SOT-23
D4, D5, D6, D7, D8, D9, D10, D11: LED_Small_Filled; LED_D3.0mm_JLCPCB
H1, H2: MountingHole; MountingHole_2.2mm_M2
H3, H4, H5, H6: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
J2, J6: 5077CR-16-SMC2-BK-TR; USB_C_5077CR-16-SMC2-BK-TR
J3: 47219-2001; Molex_47219-2001
J4, J5: 43045-0400; Molex_Micro-Fit_3.0_43045-0400_2x02_P3.00mm_Horizontal
J7: S-037-TGG; SMA_S-037-TGG_Horizontal
L1: LQW18AN27NJ00D; L_0603_1608Metric
R1, R2, R3, R4, R6, R8, R9, R20, R21, R22, R23, R32, R36, R45, R49: 10k; R_0603_1608Metric
R5, R7, R14, R15, R26, R39, R40, R41, R42, R43, R44, R46, R48, R50, R51: 1k; R_0603_1608Metric
R10, R11: 100; R_0603_1608Metric
R12, R16: 2k; R_0603_1608Metric
R13, R18: 13k; R_0603_1608Metric
R17: 49.9k; R_0603_1608Metric
R19: 4.99k; R_0603_1608Metric
R24, R25: 68k; R_0603_1608Metric
R27, R35: 120; R_0603_1608Metric
R28: 100k; R_0603_1608Metric
R29: 330; R_0603_1608Metric
R30, R47: 10; R_0603_1608Metric
R31: 390k; R_0603_1608Metric
R33: 200k; R_0603_1608Metric
R34: 510k; R_0603_1608Metric
R37, R38: 22; R_0603_1608Metric
U1: NJM2845DL1-05; TO-252-3_TabPin2
U2: LDR6321; SSOP-16_3.9x4.9mm_P0.635mm
U3: ESP32-S3-WROOM-1-N16R8; ESP32-S3-WROOM-1
U4: BP5293-33; BP5293_33_SIP3
U5: TCKE800NL; TCKE800NL_WSON10B
U6: OKL-T/6-W12N-C; OKL_T_6_W12N_C
U7: MCP25625T-E/SS; SSOP-28_5.3x10.2mm_P0.65mm
U8: ATA6561-GAQW-N; SOIC-8_3.9x4.9mm_P1.27mm
U9: TPS2041BDBVR; SOT-23-5
U10: TUSB320IRWBR; Texas_X2QFN-12_1.6x1.6mm_P0.4mm
U11: TC74HC595AF; SOIC-16W_5.3x10.2mm_P1.27mm
U12: BNO055_module; AE_BNO055_BO
U13: MAX-M10M-00B; MAX_M10M_00B_LCC18
Y1: HUSG-20.000-20; Crystal_HC49-4H_Vertical

Connections:
+3V3: C1.1, C2.1, C8.1, C9.1, C16.1, C17.1, C27.1, C28.1, C29.1, C33.1, C36.1, J3.4 (VDD), R1.1, R2.2, R4.2, R6.2, R8.2, R9.2, R20.1, R22.1, R32.1, R33.1, R36.1, R45.1, R50.2, R51.2, U3.2 (3V3), U4.3 (VOUT), U7.1 (V_{IO}), U7.19 (V_{DD}), U8.5 (VIO), U10.12 (VDD), U11.10 (~SRCLR), U11.16 (VCC), U12.1 (V_{IN}), U13.6 (V_BCKP), U13.7 (V_IO), U13.8 (VCC)
+5V: C12.1, C13.1, C14.1, C15.1, C26.1, C32.1, J4.1, J5.1, U6.4 (VOUT), U6.5 (SENSE), U7.27 (V_{DDA}), U8.3 (VCC), U9.5 (IN)
/A105_BOOT/G0: J1.4, R20.2, U3.27 (IO0)
/A105_EN: C7.1, J1.3, R1.2, U3.3 (EN)
/A105_RxD: J1.1, R5.2
/A105_TxD: J1.2, R7.2
/CAN1_RxD: U3.39 (IO1), U8.4 (RXD)
/CAN1_TxD: U3.38 (IO2), U8.1 (TXD)
/CAN2_CS: R22.2, U3.35 (IO42), U7.17 (~CS)
/CAN2_INT: U3.24 (IO47), U7.13 (~INT)
/CAN2_MISO: U3.34 (IO41), U7.16 (SO)
/CAN2_MOSI: U3.33 (IO40), U7.15 (SI), U11.14 (SER)
/CAN2_RESET: R36.2, U3.4 (IO4), U7.18 (~RESET)
/CAN2_SCK: U3.32 (IO39), U7.14 (SCK), U11.11 (SRCLK)
/CC1: R10.1, U2.13 (CC1)
/CC2: R11.1, U2.12 (CC2)
/DCDC_IN: C18.1, C19.1, U5.6 (VOUT), U5.7 (VOUT), U5.8 (VOUT), U6.2 (VIN)
/ESP_D+: R38.1, U3.14 (USB_D+)
/ESP_D-: R37.1, U3.13 (USB_D-)
/GNSS_PPS: U3.12 (IO8), U13.4 (TIMEPULSE)
/GNSS_RESET: R45.2, U3.17 (IO9), U13.9 (RESET_N)
/GNSS_RxD: U3.8 (IO15), U13.2 (TXD)
/GNSS_TxD: U3.9 (IO16), U13.3 (RXD)
/IMU_RESET: U3.7 (IO7), U12.5 (~RESET)
/IMU_SCL: R50.1, U3.11 (IO18), U12.4 (SCL/R)
/IMU_SDA: R51.1, U3.10 (IO17), U12.3 (SDA/T)
/OTG-CC1: J6.A5 (CC1), U10.1 (CC1)
/OTG-CC2: J6.B5 (CC2), U10.2 (CC2)
/OTG_OC: R32.2, U3.31 (IO38), U9.3 (~OC)
/OTG_VBUS: C22.1, C23.1, J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS), R25.1, R31.1, U9.1 (OUT)
/OTG_VBUS_SENSE: R25.2, R28.1, U3.6 (IO6)
/SD_CLK: J3.5 (CLK), U3.19 (IO11)
/SD_CMD: J3.3 (CMD), R9.1, U3.18 (IO10)
/SD_DAT0: J3.7 (DAT0), R2.1, U3.20 (IO12)
/SD_DAT1: J3.8 (DAT1), R4.1, U3.21 (IO13)
/SD_DAT2: J3.1 (DAT2), R6.1, U3.22 (IO14)
/SD_DAT3: J3.2 (DAT3/CD), R8.1, U3.23 (IO21)
/STATUS_OUT: U3.26 (IO45), U11.12 (RCLK)
/USB_ROLE: R33.2, U3.25 (IO48), U9.4 (~EN), U10.9 (ID)
/VBUS: C3.1, C20.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R17.1, U1.1 (IN), U4.1 (VIN), U5.3 (VIN), U5.4 (VIN), U5.5 (VIN)
/VBUSEN: R23.1, U2.11 (VBUSEN), U5.2 (EN/UVLO)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C32.2, C33.2, C34.2, C36.2, D2.3 (GND), D3.3 (GND), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), J1.5, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.6 (VSS), J3.9 (SHIELD), J4.4, J5.4, J6.A1 (GND), J6.A12 (GND), J6.B1 (GND), J6.B12 (GND), J6.S1 (SHIELD), J7.2 (Ext), R3.2, R19.2, R21.2, R23.2, R24.2, R28.2, R30.2, R49.2, U1.2 (GND), U2.1 (VSS), U3.1 (GND), U3.40 (GND), U3.41 (GND), U4.2 (GND), U5.11 (GND), U6.1 (ON/OFF), U6.3 (GND), U6.7 (GND), U7.5 (STBY), U7.10 (GND), U7.26 (V_{SS}), U8.2 (GND), U8.8 (STBY), U9.2 (GND), U10.10 (GND), U10.11 (~EN), U11.8 (GND), U11.13 (~OE), U12.2 (GND), U12.7 (GND), U13.1 (GND), U13.10 (GND), U13.12 (GND)
unnamed: C34.1, R47.2
unnamed: C4.1, D1.2 (A), U1.3 (OUT)
unnamed: C5.1, C6.1, D1.1 (K), R3.1, U2.16 (VDD)
unnamed: D2.1 (LINE1), J4.2, R27.2, U7.4 (CANH)
unnamed: D2.2 (LINE2), J4.3, R27.1, U7.3 (CANL)
unnamed: D3.1 (LINE1), J5.2, R35.2, U8.7 (CANH)
unnamed: D3.2 (LINE2), J5.3, R35.1, U8.6 (CANL)
unnamed: D4.2 (A), R39.2
unnamed: D5.2 (A), R40.2
unnamed: D6.2 (A), R41.2
unnamed: D7.2 (A), R42.2
unnamed: D8.2 (A), R43.2
unnamed: D9.2 (A), R44.2
unnamed: D10.2 (A), R46.2
unnamed: D11.2 (A), R48.2
unnamed: J2.A5 (CC1), R10.2
unnamed: J2.B5 (CC2), R11.2
unnamed: J2.A6 (D+), J2.B6 (D+), R15.1, R16.1, R18.1
unnamed: J2.A7 (D-), J2.B7 (D-), R12.1, R13.1, R14.1
unnamed: J6.A6 (D+), J6.B6 (D+), R38.2
unnamed: J6.A7 (D-), J6.B7 (D-), R37.2
unnamed: J7.1 (In), L1.1, U13.11 (RF_IN)
unnamed: R26.2, R29.1
unnamed: R29.2, R30.1
unnamed: R31.2, R34.1
unnamed: R13.2, U2.9 (ADC_D-)
unnamed: R18.2, U2.7 (DOWN_D+)
unnamed: R15.2, U2.5 (EN_D+)
unnamed: C11.1, U2.15 (PDLDO)
unnamed: R16.2, U2.6 (QC_EN+)
unnamed: R12.2, U2.8 (QC_EN-)
unnamed: R14.2, U2.10 (UP_D-)
unnamed: R21.1, U2.2 (VCON0)
unnamed: C10.1, R17.2, R19.1, U2.14 (VREF)
unnamed: R7.1, U3.36 (RXD0)
unnamed: R5.1, U3.37 (TXD0)
unnamed: R24.1, U5.10 (ILIM)
unnamed: C21.1, U5.1 (dV/dT)
unnamed: R26.1, U6.6 (TRIM)
unnamed: C24.1, U7.9 (OSC1), Y1.2
unnamed: C25.1, U7.8 (OSC2), Y1.1
unnamed: U7.21 (RxCAN), U7.28 (R_{XD})
unnamed: U7.20 (TxCAN), U7.24 (T_{XD})
unnamed: R34.2, U10.4 (VBUS_DET)
unnamed: R39.1, U11.15 (QA)
unnamed: R40.1, U11.1 (QB)
unnamed: R41.1, U11.2 (QC)
unnamed: R42.1, U11.3 (QD)
unnamed: R43.1, U11.4 (QE)
unnamed: R44.1, U11.5 (QF)
unnamed: R46.1, U11.6 (QG)
unnamed: R48.1, U11.7 (QH)
unnamed: R49.1, U13.13 (LNA_EN)
unnamed: L1.2, R47.1, U13.14 (VCC_RF)

Notes on the sheet:
UART
金属皮膜(±1%)
LQG15HS27NJ02D

Board: 2 copper layers, 70.6 x 100.0 mm, 123 parts (10 on the bottom side), 96 nets.

## KiCad design circuit/logger_v2/output/design_review_20260907/silkscreen_work/synced_finished.kicad_pcb

Board: 2 copper layers, 68.6 x 53.3 mm, 63 parts (0 on the bottom side), 46 nets.

Parts:
C1, C4, C5, C6, C7, C8, C9, C10, C12: 100nF; C_0603_1608Metric
C2, C3: 18pF; C_0603_1608Metric
C11: 1uF; C_0603_1608Metric
C13, C14: 10uF; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8: GREEN 0805; LED_0805_2012Metric
D9, D10: NUP2105LT1G; SOT-23
D11: RF ESD; D_SOD-882
J1: S-037-TGG; SMA_S-037-TGG_Horizontal
J2: Digital/PWM; PinSocket_1x10_P2.54mm_Vertical
J3: Power; PinSocket_1x08_P2.54mm_Vertical
J4: Analog; PinSocket_1x06_P2.54mm_Vertical
J5: Digital/PWM; PinSocket_1x08_P2.54mm_Vertical_ShieldCorner
J6, J7: 43045-0400; Molex_Micro-Fit_3.0_43045-0400_2x02_P3.00mm_Horizontal
L1: 27nH; L_0402_1005Metric
MH1, MH2, MH3, MH4: MountingHole_3.2mm
R1, R2, R3, R4, R6, R8, R9, R11: 680R; R_0603_1608Metric
R5, R10, R12, R17: 10k; R_0603_1608Metric
R7: 27R 1W; R_2512_6332Metric
R13, R14: 120; R_0603_1608Metric
R15, R16: 4.7k; R_0603_1608Metric
R18, R19, R20: 47k; R_0603_1608Metric
U1: 74HC595D,118; SOIC-16_3.9x9.9mm_P1.27mm
U2: NEO-M9N-00B; ublox_NEO
U3: BNO055_module; AE_BNO055_BO
U4: ATA6561-GAQW; SOIC-8_3.9x4.9mm_P1.27mm
U5: MCP25625-E/SS; SSOP-28_5.3x10.2mm_P0.65mm
Y1: 20MHz 12pF; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C4.1, C6.1, C7.1, C8.1, C10.1, C11.1, C12.1, C13.1, J3.4, R5.1, R12.1, R15.2, R16.2, R17.1, U1.10, U1.16, U2.22, U2.23, U3.1, U4.1, U4.5, U5.1, U5.19
+5V: C5.1, C9.1, C14.1, J3.5, J6.1, U4.3, U5.27
/CAN1_RXD: J5.3, U4.4
/CAN2_CS_N: J2.8, R12.2, U5.17
/CAN2_INT_N: J2.9, U5.13
/CAN2_RESET_N: J2.10, R17.2, U5.18
/GNSS_PPS: J5.2, U2.3
/GNSS_RESET_N: J5.5, R5.2, U2.8
/GNSS_RF: D11.2, J1.1, L1.1, U2.11
/GNSS_RXD: J5.7, U2.21
/GNSS_TXD: J5.8, U2.20
/IMU_RESET_N: J5.6, U3.5
/IMU_SCL: J2.1, R15.1, U3.4
/IMU_SDA: J2.2, R16.1, U3.3
/SPI2_MISO: J2.6, U5.16
/SPI2_MOSI: J2.7, R18.1, U1.14, U5.15
/SPI2_SCK: J2.5, R19.1, U1.11, U5.14
/STATUS_LATCH: J5.1, R20.1, U1.12
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D1.1, D2.1, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, D9.3, D10.3, D11.1, J1.2, J2.4, J3.6, J3.7, J6.4, J7.4, R10.2, R18.2, R19.2, R20.2, U1.8, U1.13, U2.7, U2.10, U2.12, U2.13, U2.24, U3.2, U3.7, U4.2, U4.8, U5.5, U5.10, U5.26, Y1.2, Y1.4
unnamed: C1.1, L1.2, R7.2
unnamed: D1.2, R1.2
unnamed: D2.2, R2.2
unnamed: D3.2, R3.2
unnamed: D4.2, R4.2
unnamed: D5.2, R6.2
unnamed: D6.2, R8.2
unnamed: D7.2, R9.2
unnamed: D8.2, R11.2
unnamed: D9.1, J6.2, R13.2, U5.4
unnamed: D9.2, J6.3, R13.1, U5.3
unnamed: D10.1, J7.2, R14.2, U4.7
unnamed: D10.2, J7.3, R14.1, U4.6
unnamed: R1.1, U1.15
unnamed: R2.1, U1.1
unnamed: R3.1, U1.2
unnamed: R4.1, U1.3
unnamed: R6.1, U1.4
unnamed: R8.1, U1.5
unnamed: R9.1, U1.6
unnamed: R11.1, U1.7
unnamed: R10.1, U2.14
unnamed: R7.1, U2.9
unnamed: C2.1, U5.9, Y1.3
unnamed: C3.1, U5.8, Y1.1
unnamed: U5.21, U5.28
unnamed: U5.20, U5.24

File circuit/logger_v2/output/design_review_20260907/parts_sourcing.csv (part):

"Reference","Existing_part","Proposed_part","Manufacturer","LCSC","JLC_library","JLC_assembly","Package","Stock_reported","Stock_evidence","Checked_JST","Status","URL","Notes"
"U1","TC74HC595AF","74HC595D,118","Nexperia","C5947","Basic","Economic and Standard","SOIC-16 3.9mm","302263","JLC indexed page snapshot","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/Nexperia-74HC595D118/C5947","Change footprint from 5.3mm SOP; same logic pinout"
"U2","NEO-M9N-00B","NEO-M9N-00B","u-blox","C5119087","Extended","Standard Only","SMD-24P","500","JLC indexed page snapshot; current page confirms Standard Only","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/UBLOX-NEO_M9N00B/C5119087","LCSC separately showed 322; do not confuse supplier stock with allocated PCBA stock"
"U3","AE-BNO055-BO","AE-BNO055-BO","Akizuki","","Unconfirmed","Excluded from SMT BOM/CPL; post-assembly","18x11mm module","TBD","No exact JLC registration verified","2026-09-07","Selected post-assembly","https://akizukidenshi.com/catalog/g/g116996/","Use module-specific BOM; never assign bare BNO055 C93216 to this footprint"
"U3 alternative","AE-BNO055-BO","BNO055","Bosch Sensortec","C93216","Extended","Standard Only","LGA-28 5.2x3.8mm","8957","JLC category indexed stock snapshot","2026-09-07","Alternative only","https://jlcpcb.com/partdetail/BoschSensortec-BNO055/C93216","Requires full circuit redesign around same sensor IC and axis validation"
"U4","ATA6561-GAQW-N","ATA6561-GAQW","Microchip","C2929602","Extended","SMT listed; service class not displayed","SOIC-8","1117","LCSC stock only; JLC quantity not displayed","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/MicrochipTech-ATA6561GAQW/C2929602","AEC-Q100 version instead of industrial -N; confirm ordering allocation"
"U5","MCP25625T-E/SS","MCP25625-E/SS","Microchip","C184944","Extended","Economic and Standard","SSOP-28 5.3mm","86","JLC indexed page snapshot; indexed 10 months ago","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/MicrochipTech-MCP25625_ESS/C184944","T suffix changes reel packaging; same IC and SSOP; stock must be refreshed at order"
"D1-D8","3mm THT LED","KT-0805G","Hubei KENTO","C2297","Basic","Economic and Standard","0805","1845064","JLC category page indexed today","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/KT-0805G/C2297","Green Vf2.6-3.1V at5mA; selected680ohm resistors; verify actual low-current brightness"
"D9-D10","PEC3824C2A-AU","NUP2105LT1G","onsemi","C14486","Extended","SMT listed","SOT-23","190745","JLC indexed page snapshot","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/NUP2105LT1G/C14486","Pin1/2 line pin3 common; 24V 30pF max; standard part is not SZ automotive-qualified variant"
"D11","new RF ESD","PESD5V0F1BL,315","Nexperia","C45961","Extended","Economic and Standard","SOD882 DFN1006-2","18223","JLC indexed page snapshot","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/Nexperia-PESD5V0F1BL315/C45961","0.4pF typ bidirectional RF ESD; mount at SMA"
"L1","27nH unspecified","LQG15HS27NJ02D","Murata","C12669","Extended","Economic and Standard","0402","InStock quantity unverified","Current JLC structured availability; no quantity displayed","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/LQG15HS27NJ02D/C12669","27nH 350mA DCR0.46ohm SRF1.7GHz; footprint changes from0603"
"L1 alternate","27nH unspecified","LQG15HZ27NH02D","Murata","C237452","Extended","Economic and Standard","0402","1096","JLC indexed page snapshot","2026-09-07","Alternative if allocation unavailable","https://jlcpcb.com/partdetail/MurataElectronics-LQG15HZ27NH0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","27nH 3percent AEC-Q200; confirm RF curve for final selected choke"
"Y1","HUSG-20.000-20","XC2EL89COO-114YLC-20M","YXC","C18213008","Extended","Economic and Standard","SMD3225-4P","4098","JLC indexed page snapshot","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/19387115-XC2EL89COO_114YLC20M/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","20MHz CL12pF ESR70ohm -40to125C; C2/C3 must match12pF load"
"Y1 alternate","HUSG-20.000-20","ABM8G-20.000MHZ-18-D2Y-T","Abracon","C1985763","Extended","Economic and Standard","SMD3225-4P","13","JLC indexed page snapshot; available order qty10","2026-09-07","CL18pF alternative limited stock","https://jlcpcb.com/partdetail/AbraconLLC-ABM8G_20_000MHZ_18_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","20MHz CL18pF ESR80ohm -40to85C"
"J1","S-037-TGG","S-037-TGG","COSMTEC","","Unconfirmed","Excluded from SMT BOM/CPL; post-assembly","Horizontal THT SMA","TBD","No exact JLC registration verified","2026-09-07","Selected post-assembly; orientation fixed","https://akizukidenshi.com/goodsaffix/S-037-TGG_20220729.pdf","Do not substitute generic SMA without comparing manufacturer dimensions and RF launch"
"J2-J5","UNO shield headers","UNO shield stacking headers","TBD","","Unconfirmed","Excluded from SMT BOM/CPL; post-assembly","2.54mm long-tail stacking headers","TBD","Exact manufacturer and part not specified","2026-09-07","Selected post-assembly; orientation fixed","https://docs.arduino.cc/hardware/uno-q/","Sockets alone may not provide required male shield tails; verify stand-off and UNO Q clearance"
"J6-J7","43045-0400","43045-0400","Molex","","Unconfirmed","Excluded from SMT BOM/CPL; post-assembly","Micro-Fit3.0 2x2 horizontal","TBD","No exact JLC registration verified","2026-09-07","Selected post-assembly; orientation fixed","https://www.molex.com/en-us/products/part-detail/430450400","Check exact suffix and board retention features before matching procurement alternates"
"R7 rejected original value","22R 1W","25121WJ0220T4E","UNI-ROYAL","C27258","Extended","Unconfirmed","2512","InStock quantity hidden","Current JLC HTML structured availability; separate LCSC indexed stock86200","2026-09-07","Not selected; insufficient tolerance margin","https://jlcpcb.com/partdetail/28007-25121WJ0220T4E/C27258","22ohm5%1W; 22R nominal does not prove below150mA including tolerances"
"R7","22R 1W","25121WJ0270T4E","UNI-ROYAL","C25478","Extended","Unconfirmed","2512","InStock quantity hidden","Current JLC HTML structured availability","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/C25478","27ohm5%1W; below141mA at3.6V ignoring other resistance but antenna voltage lower by0.10V at20mA"
"C1/C4/C5/C6/C7/C8/C9/C10/C12","100nF or new","CC0603KRX7R9BB104","YAGEO","C14663","Basic","Economic and Standard","0603","65537578","JLC indexed today; available order51319038","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/Yageo-CC0603KRX7R9BB104/C14663","100nF X7R50V10%; C1 RF bias capacitor may share this part"
"C11","new1uF","CL10A105KB8NNNC","Samsung Electro-Mechanics","C15849","Basic","Economic and Standard","0603","9147549","JLC indexed today; available order6454019","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/C15849","1uF X5R50V10%; maximum rated temperature85C"
"C13/C14","new10uF","CL21A106KAYNNNE","Samsung Electro-Mechanics","C15850","Basic","Economic and Standard","0805","7852178","JLC indexed today; available order6491601","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/CL21A106KAYNNNE/C15850","10uF X5R25V10%; account for DC bias; maximum rated temperature85C"
"R18/R19/R20","new47k","0603WAF4702T5E","UNI-ROYAL","C25819","Basic","Economic and Standard","0603","InStock quantity hidden","Current JLC HTML structured availability","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/C25819","47k1%100mW"
"R1/R2/R3/R4/R6/R8/R9/R11","1k","0603WAF6800T5E","UNI-ROYAL","C23228","Basic","Economic and Standard","0603","InStock quantity hidden","Current JLC HTML structured availability","2026-09-07","Selected final design","https://jlcpcb.com/partdetail/0603WAF6800T5E/C23228","680ohm1%100mW; verify actual LED brightness"
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